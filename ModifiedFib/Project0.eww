<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\asm\ModifiedFib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cpp\ModifiedFib_CPP.ewp</path>
    </project>
    <batchBuild />
</workspace>
