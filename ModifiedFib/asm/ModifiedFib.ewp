# IAR project ModifiedFib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: asm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: asm.s
    ../../shared/src/: iar_boot.S
