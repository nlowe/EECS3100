# IAR project Accelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__
  AARM.AUserIncludes: ..\shared\src
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\shared\device.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: accelerometer.h accelerometer.S accelerometer_regs.h asm.s
    ../shared/: device.icf
    ../shared/src/: font13.s i2c.h i2c.S i2c_private.h iar_boot.S lcd.h lcd.s
